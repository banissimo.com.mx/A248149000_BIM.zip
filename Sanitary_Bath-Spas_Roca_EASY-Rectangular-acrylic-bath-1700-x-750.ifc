Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Bath-Spas_Roca_EASY-Rectangular-acrylic-bath-1700-x-750.ifc
Time: 2019-10-15T06:57:43
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: EASY Rectangular acrylic bath 1700 x 750
ePset_BIMobjectScript - INSTALLATION TYPE: DROP IN; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): EASY Rectangular acrylic bath 1700 x 750; SKU (BO_prodsku): 248149xx0; ManufacturName (BO_Manufac): Roca; BrandUrl (BO_brandurl): http://www.roca.com; ProductFamily (BO_prodfam): Easy; ProductGroup (BO_prodgroup): Baths; DesignCountry (BO_designcont): Spain; PublishDate (BO_publisdat): 12/14/2016; EditionNumber (BO_edinum): 1; Width (BO_width): 750; Height (BO_height): 420; Depth (BO_depth): 1700; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/roca/product/248149xx0; ProductDataUrl (BO_prodaturl): bimobject.com/roca/product/248149xx0; ProductUrl (BO_producturl): http://www.roca.com/catalogue/products/baths/rectangular-baths/without-whirlpool/acrylic-baths/rectangular-acrylic-bath-248149..0; InstallationInstructions (BO_montins): http://www.roca.com/RocaResourceServlet/resources/getMainResource?idObject={F804FDB9-B385-451E-89A1-2C541E0F0650}; TechnicalDescription (BO_techcert): http://www.roca.com/RocaResourceServlet/resources/getMainResource?idObject={17EDF6E9-1BFC-4889-9439-5E17CC214D69}; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=68jtjk-3_i4; MaterialMain (BO_mainmat): Acrylic; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Bath & Spas; BimObjectCategoryCode (BO_bocat_code): sanitary-bath-spas; IfcClassification (BO_ifcclas): Furniture; UnspcCode (BO_unspc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L7211; Uniclass14Description (BO_uniclass_1_4_desc): Baths; Uniclass20Code (BO_uniclass_2_0_code): PR-35-06-08; Uniclass20Description (BO_uniclass_2_0_desc): Baths; NBSReference (BO_nbs_ref): 35-06-08; NBSReferenceDescription (BO_nbs_desc): Baths; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
